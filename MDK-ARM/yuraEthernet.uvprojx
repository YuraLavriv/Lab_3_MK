# Keil uVision project yuraEthernet.uvprojx, settings and files
target yuraEthernet (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: yuraEthernet
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/apps/httpd;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: memp.c inet_chksum.c stats.c def.c raw.c dns.c init.c sys.c tcp_out.c mem.c tcp_in.c timeouts.c ip.c pbuf.c tcp.c udp.c netif.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chap-md5.c lcp.c ccp.c pppcrypt.c fsm.c ecp.c eui64.c chap-new.c magic.c auth.c multilink.c pppos.c upap.c eap.c vj.c chap_ms.c mppe.c ipcp.c pppoe.c ipv6cp.c pppol2tp.c demand.c ppp.c pppapi.c utils.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c dhcp6.c ethip6.c ip6.c icmp6.c mld6.c nd6.c inet6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c lowpan6.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netifapi.c api_msg.c sockets.c api_lib.c netdb.c tcpip.c netbuf.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4_frag.c igmp.c ip4.c dhcp.c ip4_addr.c etharp.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: ethernetif.c lwip.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
